# Keil uVision project car.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: car
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\start;.\User;.\Mid;.\Dri;.\Int;.\App;.\Mid\FreeRTOS\include;.\Mid\FreeRTOS\portable\MemMang;.\Mid\FreeRTOS\portable\RVDS\ARM_CM3;.\Mid\FreeRTOS\source;.\Mid\FreeRTOS;.\Com;.\Int\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start
    ./start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c
  group Com
    ./Com/: Com_Filter.c
  group Int
    ./Int/: Int_TB6612.c Int_Encoder.c Int_MPU6050.c
    ./Int/OLED/: oled.c
  group Dri
    ./Dri/: Dri_TIM.c Dri_Usart1.c Dri_I2C.c Dri_ADC.c Dri_SPI.c
  group App
    ./App/: App_Car.c
  group Mid/FreeRTOS
    ./Mid/FreeRTOS/: FreeRTOSConfig.h
  group Mid/FreeRTOS/Source
    ./Mid/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group MId/FreeRTOS/Portable
    ./Mid/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./Mid/FreeRTOS/portable/MemMang/: heap_4.c
